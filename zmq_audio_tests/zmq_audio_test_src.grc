options:
  parameters:
    generate_options: qt_gui
    id: zmq_audio_test_src
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '100'
    freq: '5'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    maxoutbuf: '1024'
    minoutbuf: '64'
    packet_len: '1'
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {state: disabled}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '50'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {state: disabled}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:5555
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', zeromq_rep_sink_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, zeromq_push_msg_sink_0, in]
- [blocks_vco_f_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1

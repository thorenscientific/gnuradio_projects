options:
  parameters:
    generate_options: qt_gui
    id: zmq_audio_test_sink
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    maxoutbuf: '1024'
    minoutbuf: '64'
    type: float
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {state: disabled}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:5555
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_tagged_stream_align_0, '0', audio_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', audio_sink_0, '1']
- [zeromq_pull_msg_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zeromq_req_source_0, '0', audio_sink_0, '0']
- [zeromq_req_source_0, '0', audio_sink_0, '1']
- [zeromq_req_source_0, '0', blocks_tagged_stream_align_0, '0']

metadata:
  file_format: 1

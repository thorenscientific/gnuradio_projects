options:
  parameters:
    generate_options: qt_gui
    id: variable_drive_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: f_a_setter.amplitude_sweeper(my_function_probe)
  states: {}
- name: freq
  id: variable
  parameters:
    value: f_a_setter.sweeper(my_function_probe)
  states: {}
- name: my_function_probe
  id: variable_function_probe
  parameters:
    block_id: probe_level
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: 'Frequency:'
    type: real
    value: freq
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    label: 'Amplitude:'
    type: real
    value: amplitude
  states: {}
- name: ampl_setter
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      a1 = 0.1
      a2 = 1.5
      a = a1
      astep = 0.1


      def sweeper(prob_lvl):
          global a1,a2,a,astep

          if(prob_lvl):#prob_lvl
              a+=astep
              print("a: ", a)
          if(a>a2):
              a=a1
              
          return a 
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: f_a_setter
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      f1 = 100
      f2 = 200
      f = f1
      step = 10

      a1 = 0.1
      a2 = 1.5
      a = a1
      astep = 0.1
      fcount = 0
      acount = 0
      def sweeper(prob_lvl):
          global f1,f2,f,step
          if(prob_lvl):#prob_lvl
              f+=step
              print("f: ", f)
          else:
              print("f sweeper called without probe")
      #        fcount += 1
          if(f>f2):
              f=f1
              
          return f

      def amplitude_sweeper(prob_lvl):
          global a1,a2,a,astep

          if(prob_lvl):#prob_lvl
              a+=astep
              print("a: ", a)
          else:
              print("a sweeper called without probe")
      #        acount += 1
          if(a>a2):
              a=a1
              
          return a 
  states: {}
- name: freq_setter
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      f1 = 100
      f2 = 200
      f = f1
      step = 10

      def sweeper(prob_lvl):
          global f1,f2,f,step
          global a1,a2,a,astep
          if(prob_lvl):#prob_lvl
              f+=step
              print("f: ", f)
          else:
              print("f sweeper called without probe...")
          if(f>f2):
              f=f1
              
          return f
  states: {state: disabled}
- name: probe_level
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', probe_level, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1

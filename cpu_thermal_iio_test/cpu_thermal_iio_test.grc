options:
  parameters:
    generate_options: qt_gui
    id: cpu_thermal_iio_test
    output_language: python
    title: CPU Temperature
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.001'
    type: float
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: input
    channel: temp1
    device: hwmon0
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1'
    type: '1'
    update_interval_ms: '1000'
    uri: 'local:'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: '80.0'
    min: '30.0'
    name: '"CPU Temperature"'
    type: float
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [iio_attr_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1

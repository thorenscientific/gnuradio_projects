options:
  parameters:
    generate_options: qt_gui
    id: adxl345_sound_effect_attempt_1
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: '100'
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '50'
  states: {}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '50'
  states: {}
- name: iio_attr_source_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"accel_y"'
    device: '"adxl345"'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '10'
    uri: '"local:"'
  states: {}
- name: iio_attr_source_0_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"accel_z"'
    device: '"adxl345"'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '10'
    uri: '"local:"'
  states: {state: disabled}
- name: iio_attr_source_0_0_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"accel_x"'
    device: '"adxl345"'
    maxoutbuf: '20'
    minoutbuf: '10'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '10'
    uri: '"local:"'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: X Accel
    label2: Y Accel
    label3: Z Accel
    name: '"Accelerometer"'
    nconnections: '3'
    size: '128'
    srate: '10'
    type: float
    ylabel: '"Acceleration"'
    ymax: '256'
    ymin: '-256'
    yunit: '"g"'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: X Accel
    label2: Y Accel
    name: '"Audio"'
    nconnections: '2'
    size: '1028'
    srate: samp_rate
    type: float
    update_time: '0.250'
    ylabel: '"Acceleration"'
    ymax: '2'
    ymin: '-2'
    yunit: '"g"'
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_sample_and_hold_xx_0, '1']
- [blocks_sample_and_hold_xx_0, '0', blocks_vco_f_0, '0']
- [blocks_sample_and_hold_xx_0, '0', blocks_vco_f_0_0, '0']
- [blocks_vco_f_0, '0', audio_sink_0, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vco_f_0_0, '0', audio_sink_0, '1']
- [blocks_vco_f_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [iio_attr_source_0_0, '0', blocks_sample_and_hold_xx_0, '0']
- [iio_attr_source_0_0, '0', qtgui_time_sink_x_0, '1']
- [iio_attr_source_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [iio_attr_source_0_0_0_0, '0', blocks_vco_f_0, '0']
- [iio_attr_source_0_0_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1

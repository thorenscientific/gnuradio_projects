options:
  parameters:
    generate_options: qt_gui
    id: m2k_am_to_fm_pluto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bp_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fx_decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: osr
  id: variable
  parameters:
    value: '51'
  states: {}
- name: rr_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rr_interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate/(osr*fx_decim))
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(samp_rate/(osr*fx_decim))
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: bp_decim
    gain: '1'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '500'
    samp_rate: samp_rate/(osr*fx_decim)
    type: fir_filter_fff
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '505000'
    decim: fx_decim
    samp_rate: samp_rate/osr
    taps: firdes.low_pass(1,(samp_rate/osr),(samp_rate/osr)/(2*fx_decim), 2000)
    type: fcc
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1024'
    type: '0'
    update_interval_ms: '1'
    uri: 'local:'
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '88500000'
    samplerate: '600000'
    uri: ip:192.168.2.1
  states: {}
- name: m2k_analog_in_source_0
  id: m2k_analog_in_source
  parameters:
    buffer_size: '16384'
    calibrateADC: 'True'
    enable_ch1: 'True'
    enable_ch2: 'False'
    kernel_buffers: '4'
    oversampling_ratio: osr
    range_1: '0'
    range_2: '0'
    sampling_frequency: samp_rate
    trigger_condition_ch1: '2'
    trigger_condition_ch2: '0'
    trigger_delay: '0'
    trigger_level_ch1: '0'
    trigger_level_ch2: '0'
    trigger_mode_ch1: '0'
    trigger_mode_ch2: '0'
    trigger_source: '0'
    type: 'True'
    uri: ip:192.168.3.231
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Raw Digitized I.F."'
    size: '16384'
    srate: samp_rate/(osr)
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Translated I.F."'
    size: '16384'
    srate: samp_rate/(osr*16)
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Demodulated Baseband"'
    size: '16384'
    srate: samp_rate/(osr*fx_decim)
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Audio"'
    size: '16384'
    srate: int(samp_rate*rr_interp/(osr*fx_decim*bp_decim*rr_decim))
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rr_decim
    fbw: '0.8'
    interp: rr_interp
    taps: '128'
    type: fff
  states: {}

connections:
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [band_pass_filter_0, '0', analog_wfm_tx_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_1, '0', band_pass_filter_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_1, '0']
- [iio_attr_source_0, '0', blocks_null_sink_0, '0']
- [m2k_analog_in_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [m2k_analog_in_source_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_1_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: first_m2k
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '50'
  states: {}
- name: osr
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '505000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/osr
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: '32000'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '20'
    gain: '1'
    samp_rate: samp_rate/osr
    type: fir_filter_ccf
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: m2k_analog_in_source_0
  id: m2k_analog_in_source
  parameters:
    buffer_size: '32768'
    calibrateADC: 'True'
    enable_ch1: 'True'
    enable_ch2: 'False'
    kernel_buffers: '16'
    oversampling_ratio: osr
    range_1: '0'
    range_2: '0'
    sampling_frequency: samp_rate
    trigger_condition_ch1: '2'
    trigger_condition_ch2: '0'
    trigger_delay: '0'
    trigger_level_ch1: '0'
    trigger_level_ch2: '0'
    trigger_mode_ch1: '0'
    trigger_mode_ch2: '0'
    trigger_source: '0'
    type: 'True'
    uri: ip:192.168.3.231
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '16384'
    srate: samp_rate/(10*osr)
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    fbw: '0.8'
    interp: '8'
    taps: '32'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_complex_to_imag_0, '0']
- [analog_sig_source_x_1, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_1, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_1, '0']
- [m2k_analog_in_source_0, '0', blocks_multiply_xx_0, '0']
- [m2k_analog_in_source_0, '0', blocks_multiply_xx_0_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: m2k_am_if_to_fm_pluto_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fx_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '475000'
  states: {}
- name: lp_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: osr
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rr_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rr_interp
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 90e6
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate/(osr*fx_decim*lp_decim))
    fh: '-1.0'
    max_dev: 150e3
    quad_rate: tx_samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: '32000'
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_freq
    decim: fx_decim
    samp_rate: samp_rate/osr
    taps: firdes.low_pass(1,(samp_rate/osr),(samp_rate/osr)/(2*fx_decim), 20000)
    type: fcc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    auto_filter: 'True'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(tx_freq)
    samplerate: tx_samp_rate
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: lp_decim
    gain: '1'
    samp_rate: samp_rate/(osr*fx_decim)
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: m2k_analog_in_source_0
  id: m2k_analog_in_source
  parameters:
    buffer_size: '16384'
    calibrateADC: 'True'
    enable_ch1: 'True'
    enable_ch2: 'False'
    kernel_buffers: '4'
    oversampling_ratio: osr
    range_1: '0'
    range_2: '0'
    sampling_frequency: samp_rate
    trigger_condition_ch1: '2'
    trigger_condition_ch2: '0'
    trigger_delay: '0'
    trigger_level_ch1: '0'
    trigger_level_ch2: '0'
    trigger_mode_ch1: '0'
    trigger_mode_ch2: '0'
    trigger_source: '0'
    type: 'True'
    uri: ip:192.168.3.1
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Raw Digitized I.F."'
    size: '16384'
    srate: samp_rate/(osr)
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Translated I.F."'
    size: '4096'
    srate: samp_rate/(osr*fx_decim)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Demodulated Baseband"'
    size: '4096'
    srate: samp_rate/(osr*fx_decim)
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Audio"'
    size: '16384'
    srate: int(samp_rate*rr_interp/(osr*fx_decim*bp_decim*rr_decim))
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rr_decim
    fbw: '0.8'
    interp: rr_interp
    taps: '128'
    type: fff
  states: {}

connections:
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_mag_1, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '1']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_tx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [m2k_analog_in_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [m2k_analog_in_source_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_1_0, '0']

metadata:
  file_format: 1

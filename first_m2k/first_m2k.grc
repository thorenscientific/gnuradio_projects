options:
  parameters:
    generate_options: qt_gui
    id: first_m2k
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: m2k_ctx
  id: variable
  parameters:
    value: '"ip:192.168.3.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: m2k_analog_in_source_0
  id: m2k_analog_in_source
  parameters:
    buffer_size: '8192'
    calibrateADC: 'True'
    enable_ch1: 'True'
    enable_ch2: 'True'
    kernel_buffers: '4'
    oversampling_ratio: '1'
    range_1: '0'
    range_2: '0'
    sampling_frequency: samp_rate
    streaming: 'True'
    trigger_condition_ch1: '0'
    trigger_condition_ch2: '0'
    trigger_delay: '0'
    trigger_level_ch1: '0'
    trigger_level_ch2: '0'
    trigger_mode_ch1: '0'
    trigger_mode_ch2: '0'
    trigger_source: '0'
    type: 'True'
    uri: m2k_ctx
  states: {}
- name: m2k_analog_out_sink_0
  id: m2k_analog_out_sink
  parameters:
    buffer_size: '32768'
    calibrateDAC: 'True'
    cyclic_ch1: 'False'
    cyclic_ch2: 'False'
    kernel_buffers_ch1: '4'
    kernel_buffers_ch2: '4'
    oversampling_ratio_ch1: '1'
    oversampling_ratio_ch2: '1'
    sampling_frequency_ch1: '75000'
    sampling_frequency_ch2: '75000'
    type: 'True'
    uri: ip:192.168.3.1
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [m2k_analog_in_source_0, '0', m2k_analog_out_sink_0, '0']
- [m2k_analog_in_source_0, '0', qtgui_time_sink_x_0, '0']
- [m2k_analog_in_source_0, '1', m2k_analog_out_sink_0, '1']
- [m2k_analog_in_source_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1

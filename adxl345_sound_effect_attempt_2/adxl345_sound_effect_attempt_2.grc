options:
  parameters:
    generate_options: qt_gui
    id: adxl345_sound_effect_attempt_2
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '20'
    freq: '.5'
    offset: '20'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '50'
  states: {}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '50'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import adi


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.single],
                  out_sig=[np.single]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.myacc=adi.adxl345(uri="local:")

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] =  input_items[0] * int(self.myacc.accel_z.raw)# np.average(input_items[0])*
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: X Accel
    label2: Y Accel
    name: '"Audio"'
    nconnections: '2'
    size: '1028'
    srate: samp_rate
    type: float
    update_time: '0.250'
    ylabel: '"Acceleration"'
    ymax: '2'
    ymin: '-2'
    yunit: '"g"'
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [blocks_vco_f_0, '0', audio_sink_0, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vco_f_0_0, '0', audio_sink_0, '1']
- [blocks_vco_f_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [epy_block_0, '0', blocks_vco_f_0, '0']
- [epy_block_0, '0', blocks_vco_f_0_0, '0']

metadata:
  file_format: 1

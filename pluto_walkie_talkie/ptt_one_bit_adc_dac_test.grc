options:
  parameters:
    generate_options: qt_gui
    id: one_bit_adc_dac_test
    output_language: python
    title: One Bit ADC DAC test
  states: {}

blocks:
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"voltage0"'
    device: '"one-bit-adc-dac"'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1'
    type: '1'
    update_interval_ms: '10'
    uri: '"local:"'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '10'
    srate: '10'
    type: float
    update_time: '1'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}

connections:
- [iio_attr_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1

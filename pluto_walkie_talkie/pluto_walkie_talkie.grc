options:
  parameters:
    generate_options: qt_gui
    id: pluto_walkie_talkie
    output_language: python
    title: Pluto Walkie Talkie
  states: {}

blocks:
- name: aud_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: pluto_ctx
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '94100000'
  states: {}
- name: rx_starve
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2304000//2
  states: {}
- name: transition
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '94100000'
  states: {}
- name: tx_starve
  id: variable
  parameters:
    value: '1'
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: real
    value: '0'
    writeback: None
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: aud_samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(samp_rate // 8)
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: aud_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: quadrature
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: aud_samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: aud_samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"voltage0"'
    device: '"one-bit-adc-dac"'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1'
    type: '1'
    update_interval_ms: '100'
    uri: '"local:"'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    auto_filter: 'True'
    bandwidth: '200000'
    buffer_size: '8192'
    cyclic: 'False'
    frequency: tx_freq
    samplerate: '2084000'
    uri: pluto_ctx
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '8192'
    frequency: rx_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2084000'
    uri: pluto_ctx
  states: {}
- name: interpolation
  id: parameter
  parameters:
    label: Interpolation
    type: intx
    value: '2'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: '1.5'
    min: '-0.5'
    type: float
    update_time: '0.2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature/1e3/audio_dec)
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(8 / interpolation)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/quadrature)
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_sig_source_x_0, '0', audio_sink_0_0, '0']
- [analog_sig_source_x_0, '0', audio_sink_0_0, '1']
- [analog_sig_source_x_0_0, '0', analog_nbfm_tx_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '1']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_1, '0']
- [audio_source_0, '0', rational_resampler_xxx_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_0, '0', low_pass_filter_0, '0']
- [blocks_null_source_0_0, '0', analog_nbfm_tx_0, '0']
- [iio_attr_source_0, '0', qtgui_number_sink_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_null_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_null_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_1_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1

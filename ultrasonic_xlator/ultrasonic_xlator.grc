options:
  parameters:
    generate_options: qt_gui
    id: first_m2k
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: I_F
  id: variable_qtgui_range
  parameters:
    label: '""'
    min_len: '1000'
    orient: Qt.Vertical
    start: '37000'
    step: '10'
    stop: '43000'
    value: '39000'
    widget: slider
  states: {}
- name: Vol
  id: variable_qtgui_range
  parameters:
    label: '"Volume"'
    min_len: '1000'
    orient: Qt.Vertical
    start: '0.1'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
    widget: slider
  states: {}
- name: decim
  id: variable
  parameters:
    value: '100'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '48'
  states: {}
- name: m2k_ctx
  id: variable
  parameters:
    value: '"ip:192.168.3.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: '"Intermediate Freq."'
    type: int
    value: I_F
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: Volume control
    const: Vol
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Local Oscillator
    freq: I_F
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      Send to sound card!!
      (Same to L and R)
    num_inputs: '2'
    samp_rate: int(samp_rate*interp/decim)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    comment: Split complex LO to I/Q
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: I demodulator
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: Q demodulator
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    comment: Apply volume control
    type: float
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    comment: Remove DC content
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: m2k_analog_in_source_0
  id: m2k_analog_in_source
  parameters:
    buffer_size: '8192'
    calibrateADC: 'True'
    enable_ch1: 'True'
    enable_ch2: 'False'
    kernel_buffers: '4'
    oversampling_ratio: '1'
    range_1: '1'
    range_2: '1'
    sampling_frequency: samp_rate
    streaming: 'True'
    trigger_condition_ch1: '0'
    trigger_condition_ch2: '0'
    trigger_delay: '0'
    trigger_level_ch1: '0'
    trigger_level_ch2: '0'
    trigger_mode_ch1: '0'
    trigger_mode_ch2: '0'
    trigger_source: '0'
    type: 'True'
    uri: m2k_ctx
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Plot raw data
    name: '"Raw Data"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: Plot translated signal
    name: '"Translated Output"'
    size: '1024'
    srate: int(samp_rate*interp/decim)
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Sample rate conversion
      to something the sound
      card can swallow
    decim: decim
    fbw: '0.4'
    interp: interp
    taps: ''
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_1, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0_1, '0', audio_sink_0, '1']
- [high_pass_filter_0_0, '0', blocks_multiply_xx_0, '0']
- [high_pass_filter_0_0, '0', blocks_multiply_xx_0_0, '1']
- [m2k_analog_in_source_0, '0', high_pass_filter_0_0, '0']
- [m2k_analog_in_source_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: adxl345_sound_effect_3p8
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '25'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '1'
  states: {}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '1'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import random


      #import sys
      import zmq

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='0MQ_RX_adxl345',   # will show up in GRC
                  in_sig=[np.single],
                  out_sig=[np.single, np.single, np.single]
                  
              )
              random.seed()
      #        print("version: " + sys.version)
              port = "5556"

              # Socket to talk to server
              context = zmq.Context()
      #         self.socket = context.socket(zmq.SUB)
      #         self.socket.connect ("tcp://localhost:%s" % port)
      #          topicfilter = "10001"
      #         #self.socket.setsockopt_string(zmq.SUBSCRIBE, topicfilter)

      #    def work(self, input_items, output_items):
          def work(self, input_items, output_items):
              """Scale input with acceleration values, send to 3 outputs"""
              try:
      #            self.st = self.socket.recv(flags=zmq.NOBLOCK) # If nothing published, move on
      #            print("got string...:" + str(self.st))
      #            topic, self.xst, self.yst, self.zst = self.st.split()
                  self.xst = random.randint(-256, 256)
                  self.yst = random.randint(-256, 256)
                  self.zst = random.randint(-256, 256)

              except:
                  pass
              
              output_items[0][:] = input_items[0] * (float(self.xst)+256.0) # add offset to keep positive
              output_items[1][:] = input_items[0] * (float(self.yst)+256.0)
              output_items[2][:] = input_items[0] * (float(self.zst)+256.0)
              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '0']
- [blocks_add_xx_0, '0', blocks_vco_f_0, '0']
- [blocks_add_xx_0_0, '0', blocks_vco_f_0_0, '0']
- [blocks_vco_f_0, '0', audio_sink_0, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vco_f_0_0, '0', audio_sink_0, '1']
- [blocks_vco_f_0_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_0, '0', blocks_add_xx_0, '0']
- [epy_block_0, '1', blocks_add_xx_0, '1']
- [epy_block_0, '1', blocks_add_xx_0_0, '0']
- [epy_block_0, '2', blocks_add_xx_0_0, '1']

metadata:
  file_format: 1

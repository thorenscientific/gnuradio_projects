options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: iio_attr_source_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"accel_y"'
    device: '"adxl345"'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '10'
    uri: '"local:"'
  states: {}
- name: iio_attr_source_0_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"accel_z"'
    device: '"adxl345"'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '10'
    uri: '"local:"'
  states: {}
- name: iio_attr_source_0_0_0_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: '"raw"'
    channel: '"accel_x"'
    device: '"adxl345"'
    maxoutbuf: '20'
    minoutbuf: '10'
    output: 'False'
    required_enable: 'False'
    samples_per_update: '32'
    type: '1'
    update_interval_ms: '10'
    uri: '"local:"'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: X Accel
    label2: Y Accel
    label3: Z Accel
    nconnections: '3'
    size: '128'
    srate: '10'
    type: float
    ylabel: '"Acceleration"'
    ymax: '256'
    ymin: '-256'
    yunit: '"g"'
  states: {}

connections:
- [iio_attr_source_0_0, '0', qtgui_time_sink_x_0, '1']
- [iio_attr_source_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [iio_attr_source_0_0_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
